# IAR project eie_cprimer_simulator.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3U2C Atmel ATSAM3U2C
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: MPGL1; MPG1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..; ..\cmsis; ..\drivers; ..\application
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: eie_cprimer_simulator.hex
  ILINK.IlinkOutputFile: eie_cprimer_simulator
  ILINK.IlinkIcfFile: ..\sam3u2-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group _BSP/Includes
    ../: AT91SAM3U4.h configuration.h typedefs.h
    ../drivers/: exceptions.h interrupts.h
  group _BSP/Source
    ../: board_cstartup_iar.c
    ../drivers/: exceptions.c
    ../application/: refreshledmatrix.s
  group _CMSIS
    ../cmsis/: core_cm3.c core_cm3.h
  group Application/Include
    ../application/: main.h main_solution.h
    ../drivers/: utilities.h
  group Application/Source
    ../application/: main.c main_solution.c main_solution_framework.c
    ../drivers/: utilities.c
