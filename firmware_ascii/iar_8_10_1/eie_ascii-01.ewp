# IAR project eie_ascii-01.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3U2C Atmel ATSAM3U2C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EIE_ASCII
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\bsp; ..\drivers; ..\application; ..\..\firmware_common; ..\..\firmware_common\application; ..\..\firmware_common\application\blade; ..\..\firmware_common\bsp; ..\..\firmware_common\cmsis; ..\..\firmware_common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; ..\bsp; ..\drivers; ..\application; ..\..\firmware_common; ..\..\firmware_common\application; ..\..\firmware_common\cmsis; ..\..\firmware_common\drivers
  OBJCOPY.OOCOutputFile: eiefw-01.hex
  ILINK.IlinkOutputFile: eie_ascii-01.out
  ILINK.IlinkIcfFile: $PROJ_DIR$l\..\..\firmware_common\bsp\sam3u2-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group _BSP/Includes
    ../../firmware_common/bsp/: AT91SAM3U4.h configuration.h sam3u2-flash.icf typedefs.h
    ../bsp/: eief1-pcb-01.h
  group _BSP/Source
    ../../firmware_common/bsp/: board_cstartup_iar.c kill_x_cycles.s
    ../bsp/: eief1-pcb-01.c
  group _CMSIS
    ../../firmware_common/cmsis/: core_cm3.h
  group _Drivers/Include
    ../../firmware_common/drivers/: adc12.h ant.h ant_api.h antdefines.h antmessage.h buttons.h exceptions.h interrupts.h leds.h messaging.h sam3u_i2c.h sam3u_spi.h sam3u_ssp.h sam3u_uart.h timer.h utilities.h
    ../drivers/: lcd_nhd-c0220biz.h
  group _Drivers/Source
    ../../firmware_common/drivers/: adc12.c ant.c ant_api.c buttons.c exceptions.c interrupts.c leds.c messaging.c sam3u_i2c.c sam3u_spi.c sam3u_ssp.c sam3u_uart.c timer.c utilities.c
    ../drivers/: lcd_nhd-c0220biz.c
  group Application/Blades
    ../../firmware_common/application/: blade.readme
  group Application/Blades/Include
    ../../firmware_common/application/blade/: blade_api.h blade_imu_lsm9ds1.h
  group Application/Blades/Source
    ../../firmware_common/application/blade/: blade_api.c blade_imu_lsm9ds1.c
  group Application/Include
    ../../firmware_common/application/: debug.h main.h music.h user_app1.h user_app2.h user_app3.h
  group Application/Source
    ../../firmware_common/application/: debug.c main.c user_app1.c user_app2.c user_app3.c
